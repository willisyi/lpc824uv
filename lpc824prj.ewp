# IAR project lpc824prj.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_LPC824; CPU_LPC824M201JHI33
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; LPC824/iar; component/uart; device; doc; drivers; startup; utilities; LCM/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: board; source; CMSIS; LPC824/iar; component/uart; device; doc; drivers; startup; utilities
  OBJCOPY.OOCOutputFile: lpc824prj.srec
  ILINK.IlinkOutputFile: lpc824prj.out
  ILINK.IlinkIcfFile: LPC824_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_LPC824; CPU_LPC824M201JHI33
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkOutputFile: lpc_i2c_interrupt_b2b_transfer_master.out
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group component/uart
    component/uart/: miniusart_adapter.c uart.h
  group device
    device/: fsl_device_registers.h LPC824.h LPC824_features.h system_LPC824.c system_LPC824.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_swm.c fsl_swm.h fsl_swm_connections.h fsl_syscon.c fsl_syscon.h fsl_syscon_connections.h fsl_usart.c fsl_usart.h
  group LCM
    LCM/src/: chi.c eng.c logo.c SGX_G12864.C
    LCM/inc/: chi.h eng.h logo.h SGX_G12864.h
  group LPC824/iar
    LPC824/iar/: LPC824_flash.icf
  group source
    source/: lpc824uv.c
  group startup
    startup/: startup_LPC824.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
